## source/linux-5.10.168-ti-rt-r76/drivers/char/my_c_dev/Kconfig
```kconfig
menu "my custom modules"
config CUSTOM_HELLOWORLD
    tristate "Hello World module support"
    default m
endmenu
```
